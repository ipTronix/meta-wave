
IMAGE_INSTALL_append = " \
    imageflt \
"